# Keil uVision project MultirotorF4.uvproj, settings and files
target MultirotorF4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: MultirotorF4 +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\CMSIS\CM4\CoreSupport;.\lib\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\STM32F4xx_StdPeriph_Driver\src;.\lib\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group system
    ./: startup_stm32f4xx_md.s
    ./lib/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ./lib/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./lib/sys/: stm32f4xx_conf.h
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group drivers
    ./src/: drv_adc.c drv_adc_fy90q.c drv_adxl345.c drv_bmp085.c drv_hcsr04.c drv_hmc5883l.c drv_i2c.c drv_i2c_soft.c drv_l3g4200d.c drv_ledring.c drv_mma845x.c drv_mpu3050.c drv_mpu6050.c drv_ms5611.c drv_pwm.c drv_pwm_fy90q.c drv_system.c drv_uart.c
  group app
    ./src/: barofilter.c baroFusion.c buzzer.c cli.c config.c gps.c imu.c kalman1D.c kalmanFilterFrontend.c main.c mixer.c mw.c printf.c quaternion.c sensors.c serial.c simpleIntegrator.c spektrum.c telemetry.c board.h
