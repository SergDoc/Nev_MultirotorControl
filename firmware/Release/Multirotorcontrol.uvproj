# Keil uVision project Multirotorcontrol.uvproj, settings and files
target Multirotorcontrol (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Multirotorcontrol +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: .\lib;.\lib\CMSIS;.\lib\CMSIS\Include;.\lib\CMSIS\ST;.\lib\CMSIS\ST\STM32F4xx;.\lib\CMSIS\ST\STM32F4xx\Include;.\lib\CMSIS\ST\STM32F4xx\Source;.\lib\CMSIS\ST\STM32F4xx\Source\Templates;.\lib\STM32F4xx_StdPeriph_Driver;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\STM32F4xx_StdPeriph_Driver\src;.\lib\sys;.\lib\STM32_USB_Device_Library\Class\cdc\inc\;.\lib\STM32_USB_Device_Library\Class\cdc\src\;.\lib\STM32_USB_Device_Library\Core\inc\;.\lib\STM32_USB_Device_Library\Core\src\;.\lib\STM32_USB_OTG_Driver\inc\;.\lib\STM32_USB_OTG_Driver\src\;.\inc\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
  group app
    ./src/: buzzer.c cli.c config.c gps.c imu.c main.c mixer.c mw.c printf.c sensors.c serial.c spektrum.c telemetry.c board.h
  group drivers
    ./src/: drv_adc.c drv_adc_fy90q.c drv_adxl345.c drv_hcsr04.c drv_hmc5883l.c drv_i2c.c drv_i2c_soft.c drv_l3g4200d.c drv_ledring.c drv_mma845x.c drv_mpu3050.c drv_mpu6000.c drv_ms5611.c drv_pwm.c drv_pwm_fy90q.c drv_spi.c drv_system.c drv_uart.c
  group system
    ./lib/CMSIS/Include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h arm_math.h
    ./lib/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./lib/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./lib/sys/: stm32f4xx_conf.h
    ./lib/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
    ./lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ./lib/STM32_USB_Device_Library/Core/inc/: usbd_conf_template.h usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
    ./lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./lib/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_conf_template.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ./lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
